# Keil uVision project test2.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: test2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    E:/proteus_files/test1/: Test1.asm
