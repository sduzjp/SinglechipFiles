# Keil uVision project staticLED_self.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: staticLED_self +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: staticLED_self.asm
